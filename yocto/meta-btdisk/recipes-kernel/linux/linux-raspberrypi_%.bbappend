FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://btdisk.cfg"
